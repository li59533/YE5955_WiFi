# Keil uVision project stm32l4xx.uvprojx, settings and files
target stm32l4xx (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L4R9ZIJx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x000A0000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: L100 +hex
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: ICCARM,ARM_MATH_CM4,__FPU_PRESENT =1
  c include: ..\..\..\..\compoents\CMSIS\Device\ST\STM32L4xx\Include;..\..\..\..\compoents\CMSIS\Include;..\..\..\..\compoents\STM32L4xx_HAL_Driver\Inc;..\..\..\..\compoents\STM32L4xx_HAL_Driver\Inc\Legacy;..\..\..\..\compoents\Utilities;..\..\..\components\bsp\stm32l4xx_bsp\inc;..\..\..\components\mdl\clog;..\..\..\components\mdl\cshell;..\..\..\components\mdl\header;..\..\..\components\mdl\osal\ports;..\..\..\components\mdl\rttviewer;..\source;..\source\application\hal_task;..\source\application\user_task;..\source\fml\system;..\..\..\components\bsp;..\..\..\components\mdl\osal\src;..\..\..\components\bsp;..\..\..\components\bsp\stm32l4xx_bsp;..\..\..\components\bsp;..\..\..\components\mdl\freertos\inc;..\..\..\components\mdl\freertos\portable;..\source\application\first_task;..\source\application;..\..\..\components\mdl\freertos\inc;..\source\application\second_task;..\source\application\dataprocess_task;..\source\fml;..\..\..\components\mdl\freertos;..\..\..\..\compoents\CMSIS\DSP\Include;..\source\application\net_task;..\source\application\dataemu_task;..\source\application\tempareture_task;..\source\application\datasend_task;..\source\application\idle_task;..\source\application\hal_task;..\source\application\conf_task;..\source\fml\protocol
  asm include: ..\source
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0xa0000
  group Task
    ../source/application/first_task/: first_task.c
    ../source/application/second_task/: second_task.c
    ../source/application/hal_task/: hal_task.c
    ../source/application/net_task/: net_task.c
    ../source/application/dataprocess_task/: dataprocess_task.c
    ../source/application/dataemu_task/: dataemu_task.c
    ../source/application/datasend_task/: datasend_task.c
    ../source/application/tempareture_task/: temperature_task.c
    ../source/application/idle_task/: idle_task.c
    ../source/application/conf_task/: conf_task.c
  group Fml
    ../source/fml/system/: system_init.c system_param.c
    ../source/fml/: app_power.c app_datafilter.c app_dataemu.c app_datasend.c app_conf.c app_conf_net.c app_battery.c
    ../source/fml/protocol/: lnprotocol.c lnprotocol_std.c
  group Bsp
    ../../../components/bsp/: bsp_esp32.c bsp_init.c stm32_bsp_conf.h bsp_led.c bsp_ad7682.c bsp_ad7682_port.c bsp_queue.c bsp_lmt01.c bsp_lm78.c bsp_lm78_port.c double_integral.c
    ../../../components/bsp/stm32l4xx_bsp/: stm32l4xx_bsp_conf.h
    ../../../components/bsp/stm32l4xx_bsp/src/: stm32l4xx_bsp_systick.c stm32l4xx_bsp_gpio.c stm32l4xx_bsp_exti.c stm32l4xx_bsp_flash.c stm32l4xx_bsp_usart.c stm32l4xx_bsp_tim.c stm32l4xx_bsp_rtc.c stm32l4xx_bsp_spi.c
  group Mdl
    ../../../components/mdl/rttviewer/: SEGGER_RTT.c SEGGER_RTT_printf.c
    ../../../components/mdl/clog/: clog.c
  group Source
    ../source/: stm32l4xx_hal_msp.c system_stm32l4xx.c stm32l4xx_it.c main.c FreeRTOSConfig.h
    ../source/application/: task_list.c
  group Utilities
    ../../../../compoents/Utilities/: aes.c crc.c des.c md5.c tea.c version.c
  group CMSIS
    ../../../../compoents/CMSIS/Device/ST/STM32L4xx/Source/Templates/arm/: startup_stm32l4a6xx.s startup_stm32l4r5xx.s startup_stm32l4r7xx.s startup_stm32l4r9xx.s startup_stm32l4s5xx.s startup_stm32l4s7xx.s startup_stm32l4s9xx.s startup_stm32l412xx.s startup_stm32l422xx.s startup_stm32l431xx.s startup_stm32l432xx.s startup_stm32l433xx.s startup_stm32l442xx.s startup_stm32l443xx.s startup_stm32l451xx.s startup_stm32l452xx.s startup_stm32l462xx.s startup_stm32l471xx.s startup_stm32l475xx.s startup_stm32l476xx.s startup_stm32l485xx.s startup_stm32l486xx.s startup_stm32l496xx.s
  group Driver
    ../../../../compoents/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_can.c stm32l4xx_hal_comp.c stm32l4xx_hal_cortex.c stm32l4xx_hal_crc.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_cryp.c stm32l4xx_hal_cryp_ex.c stm32l4xx_hal_dac.c stm32l4xx_hal_dac_ex.c stm32l4xx_hal_dcmi.c stm32l4xx_hal_dfsdm.c stm32l4xx_hal_dfsdm_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_dma2d.c stm32l4xx_hal_dsi.c stm32l4xx_hal_exti.c stm32l4xx_hal_firewall.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gfxmmu.c stm32l4xx_hal_gpio.c stm32l4xx_hal_hash.c stm32l4xx_hal_hash_ex.c stm32l4xx_hal_hcd.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_irda.c stm32l4xx_hal_iwdg.c stm32l4xx_hal_lcd.c stm32l4xx_hal_lptim.c stm32l4xx_hal_ltdc.c stm32l4xx_hal_ltdc_ex.c stm32l4xx_hal_mmc.c stm32l4xx_hal_mmc_ex.c stm32l4xx_hal_nand.c stm32l4xx_hal_nor.c stm32l4xx_hal_opamp.c stm32l4xx_hal_opamp_ex.c stm32l4xx_hal_ospi.c stm32l4xx_hal_pcd.c stm32l4xx_hal_pcd_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_qspi.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rng.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_sai.c stm32l4xx_hal_sai_ex.c stm32l4xx_hal_sd.c stm32l4xx_hal_sd_ex.c stm32l4xx_hal_smartcard.c stm32l4xx_hal_smartcard_ex.c stm32l4xx_hal_smbus.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_sram.c stm32l4xx_hal_swpmi.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_tsc.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_usart.c stm32l4xx_hal_usart_ex.c stm32l4xx_hal_wwdg.c
  group RTOS
    ../../../components/mdl/freertos/src/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../components/mdl/freertos/portable/: port.c heap_4.c
    ../../../components/mdl/freertos/: rtos_tools.c
software components: CMSIS:CORE 5.2.0, CMSIS:DSP 1.6.0
